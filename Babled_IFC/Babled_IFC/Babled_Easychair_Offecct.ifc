Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2018-12-04T15:09:37
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150714_1515(x64) - Exporter 16.2.0.0 - Alternate UI 16.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Dec 04 15:09:37 2018 * Host: pcz-computer * Database: C:\Users\Paloma\AppData\Local\Temp\{92F67925-C046-47FF-B6D0-B1E098CBCD1F}\ifc * Database version: 5507 * Database creation date: Tue Dec 04 15:09:35 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Dec 04 15:09:36 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Dec 04 15:09:36 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 0
LongName: Level 0; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Circle Head - Project Datum; Family and Type: Level: Circle Head - Project Datum; Type: Level: Circle Head - Project Datum; Type Id: Level: Circle Head - Project Datum
Identity Data - Type Name: Circle Head - Project Datum; Building Story: yes; Name: Level 0; Structural: no
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm
Graphics - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: Anno_Level_Head_Circle: Standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: no

# IfcFurnishingElement: -, Babled_Easychair_Offecct:-:291970
In: Level 0
Type - Material: White, Kvadrat Halligndal Blue 754
Type - General - Author: Convergo AB; BIMObjectName: Babled_Easychair_Offecct; ConvergoRefNr: 0019-1812-0004-SE; ManufacturerName: Offecct; ManufacturerURL: https://www.offecct.com/; NBSDescription: Domestic chairs; NBSReference: 45-35-20/365; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_50_12_48; Uniclass2015Description: Easy chairs; Uniclass2015Reference: Pr_40_50_12_26; Version: 1; VersionDate: 29/11/2018
Type - Identity Data - Cost: 0; Designer: Emmanuel Babled; Manufacturer: Offecct; Model: Babled easy chair; OmniClass Number: 23.40.20.14.14.24; OmniClass Title: Chaises Lounges; Type Name: -; URL: https://www.offecct.com/
Type - Other - AccessibilityPerformance: n/a; AssetType: Movable; Brand: Offecct; Category: Easy chairs; CodePerformance: n/a; Color: Multiple; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: Babled_Easychair_Offecct; Features: n/a; Finish: n/a; Grade: n/a; Material: Corian & textile; ModelNumber: n/a; ModelReference: n/a; Name: Babled easy chair; ReplacementCost: n/a; Shape: Sculptured; Size: 1725x1047x1002 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: Offecct
Constraints - Host: Level : Level 0; Level: Level: Level 0; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 4.58362 m2; Volume: 1.80969 m3
Materials and Finishes - ChairMainMaterial: Kvadrat Halligndal Blue 754; ChairSecondaryMaterial: White
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Furniture; Family: Babled_Easychair_Offecct: -; Family and Type: Babled_Easychair_Offecct: -; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: Babled_Easychair_Offecct: -; Type Id: Babled_Easychair_Offecct: -; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
